# Keil uVision project project.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\oled
  group Source Group 1
    ./: main.c ADC.c ADC_Isr.c Delay.c GPIO.c I2C.c I2C_Isr.c NVIC.c STC8H_PWM.c STC8H_PWM_Isr.c Timer.c Timer_Isr.c UART.c UART_Isr.c PCF8563.c PCF8563.h Exti.c Exti_Isr.c Soft_I2C.c
  group oled
    ./oled/: oled.c
